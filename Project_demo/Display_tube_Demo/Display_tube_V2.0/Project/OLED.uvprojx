# Keil uVision project OLED.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: demo +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\OLED;..\SYSTEM\key;..\SYSTEM\led;..\SYSTEM;..\SYSTEM\Timer;..\SYSTEM\SysTick;..\SYSTEM\led;..\SYSTEM\dht11;..\SYSTEM\Display;..\SYSTEM\GeneralTim;..\SYSTEM\LightSensor;..\SYSTEM\digital_LED;..\SYSTEM\RTC
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c
    ../../OLED_Demo/OLED_Display_V1.6/USER/: stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/OLED/: oled.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/key/: bsp_key.c
    ../SYSTEM/Timer/: bsp_timer.c
    ../SYSTEM/SysTick/: bsp_SysTick.c
    ../SYSTEM/led/: bsp_led.c
    ../SYSTEM/dht11/: bsp_dht11.c
    ../SYSTEM/Display/: Display.c
    ../SYSTEM/GeneralTim/: bsp_GeneralTim.c
    ../SYSTEM/LightSensor/: light_sensor.c
    ../SYSTEM/digital_LED/: digital_led.c
    ../SYSTEM/RTC/: bsp_RTC.c bsp_date.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c
software components: CMSIS:CORE 5.4.0
